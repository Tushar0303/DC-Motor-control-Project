# Keil uVision project DC_f_r.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C51RD2Hxx NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: DC_f_r +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 dc_f_r.c
